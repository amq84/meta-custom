FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://btusb.cfg"


